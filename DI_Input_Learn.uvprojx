# Keil uVision project DI_Input_Learn.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8Hx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DI_Input_Learn
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\main;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\CoreSupport;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\DeviceSupport\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./main/: stm32f0xx_it.c main.c
  group Startup
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f051.s
  group STM32F0xx_StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_syscfg.c stm32f0xx_misc.c
  group Hardware
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
